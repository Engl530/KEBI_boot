# Keil uVision project test1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test1 +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Src
    ./: gpio.c main.c rcc.c uart.c flash.c iwdg.c tim.c
  group Inc
    ./: gpio.h main.h rcc.h uart.h flash.h iwdg.h tim.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
